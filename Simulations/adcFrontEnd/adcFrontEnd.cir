**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*                Version 1.0.00 (23/09/2011)                 *
**************************************************************

* Component Definitions
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 320p
L1 Net-_C1-Pad2_ Net-_C1-Pad1_ 800n
R1 Net-_R1-Pad1_ Net-_C1-Pad1_ 50
* Signal source (V1 Net-_R1-Pad1_ Net-_C1-Pad2_ VSOURCE)
V1 Net-_R1-Pad1_ Net-_C1-Pad2_ GENERATOR(1) AC 1.00

* GNU-Cap Simulation Commands
.OPTIONS NOPAGE
.PRINT AC VDB(C1)
.AC 1.00Meg 100.00Meg BY 10.00K TE 27.00 BASIC

.END
